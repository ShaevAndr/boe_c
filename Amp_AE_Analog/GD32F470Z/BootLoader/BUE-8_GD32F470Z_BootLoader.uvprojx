# Keil uVision project BUE-8_GD32F470Z_BootLoader.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: GD32F470ZI GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.1.0
  cpu: IRAM(0x20000000,0x0B0000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: BUE-8_GD32F470Z_BootLoader +hex
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 v6Lto=1 wLevel=3
  c define: HXTAL_VALUE=8000000 __BootLoader__
  c include: ..\LittleFS;..\Global;..\;..\..\Global;..\..\LittleFS;.\Unicorn2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0xb0000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\BUE-8_GD32F470Z_BootLoader.sct
  group Boot loader
    ./: main_bootloader.c main_bootloader.h
  group Sourse from main app
    ../: drv_ExWDT.c drv_ExWDT.h drv_LEDs.c drv_LEDs.h drv_SPI.c drv_SPI.h drv_EEPROM.c drv_EEPROM.h drv_Unicorn2EEPROM.c drv_Unicorn2EEPROM.h
  group LittleFS
    ../LittleFS/: lfs.c lfs.h lfs_storage.c lfs_storage.h lfs_util.c lfs_util.h
  group Unicorn2
    ./Unicorn2/: CommandList.h UnitDescriptionJSON.h AccessIntParam.c AccessIntParam.h AccessTelemParam.c AccessTelemParam.h AccessFlash.c AccessFlash.h CommandParser.c CommandParser.h CommandParserFunction.c CommandParserFunction.h CommandParserIntParam.c CommandParserIntParam.h CommandParserTelemParam.c CommandParserTelemParam.h CommandParserTabParam.c CommandParserTabParam.h AccessTabParam.c AccessTabParam.h CommandFlashMem.c CommandFlashMem.h crc16.c crc16.h drv_RS485x.c drv_RS485x.h drv_time.c drv_time.h drv_UUID.c drv_UUID.h PacketParser.c PacketParser.h unicorn_uart_speed.c unicorn_uart_speed.h Unicorn2Routine.c Unicorn2Routine.h crc32Ethernet.c crc32Ethernet.h
  group Global
    ../Global/: DeviceUsageStatistics.c DeviceUsageStatistics.h global.h ParamSystem.c ParamSystem.h dbg_console.c dbg_console.h logger.c logger.h drv_InternalFMC.c drv_InternalFMC.h LockUnlock.c LockUnlock.h
software components: CMSIS:CORE 5.6.0, Device:Libopt 3.0.2, Device:Startup 3.0.2, Device:StdPeripherals:FMC 3.0.2, Device:StdPeripherals:GPIO 3.0.2, Device:StdPeripherals:MISC 3.0.2, Device:StdPeripherals:PMU 3.0.2, Device:StdPeripherals:RCU 3.0.2, Device:StdPeripherals:SPI_I2S 3.0.2, Device:StdPeripherals:SYSCFG 3.0.2, Device:StdPeripherals:TIMER 3.0.2, Device:StdPeripherals:USART 3.0.2
