# Keil uVision project BUE-8_GD32F470Z.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: GD32F470ZI GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.1.0
  cpu: IRAM(0x20000000,0x0B0000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: BUE-8_GD32F470Z +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: HXTAL_VALUE=8000000,__Aplication__
  c include: .\LittleFS;.\Unicorn2;.\Global;.\Modbus
  memory RVCT4: ROM 0x8000000 size 0x1e0000
  memory RVCT9: RAM 0x20000000 size 0xb0000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\BUE-8_GD32F470Z.sct
  group Application
    ./: main_application.c main_application.h CheckEnviron.c CheckEnviron.h CheckBUE.c CheckBUE.h drv_1W.c drv_1W.h drv_DS18B20.c drv_DS18B20.h drv_EEPROM.c drv_EEPROM.h drv_ExWDT.c drv_ExWDT.h drv_LEDs.c drv_LEDs.h drv_MonADC0.c drv_MonADC0.h drv_MonADC1.c drv_MonADC1.h drv_MonADC2.c drv_MonADC2.h drv_Monp.c drv_Monp.h drv_SPI.c drv_SPI.h drv_TestPinKT.c drv_TestPinKT.h ParamApp.c ParamApp.h drv_UART.c drv_UART.h drv_ICP.c drv_ICP.h drv_KuOP.c drv_KuOP.h drv_PowerSync.c drv_PowerSync.h drv_Unicorn2EEPROM.c drv_Unicorn2EEPROM.h drv_DIn.c drv_DIn.h DeviceTemperatureStatistics.c DeviceTemperatureStatistics.h
  group Unicorn2
    ./Unicorn2/: CommandList.h AccessFloatParam.h AccessFloatParam.c AccessIntParam.c AccessIntParam.h AccessFlash.c AccessFlash.h AccessTelemParam.c AccessTelemParam.h AccessTabParam.c AccessTabParam.h CommandParser.c CommandParser.h CommandParserFloatParam.c CommandParserFloatParam.h CommandParserFunction.c CommandParserFunction.h CommandParserIntParam.c CommandParserIntParam.h CommandParserTelemParam.c CommandParserTelemParam.h CommandFlashMem.c CommandFlashMem.h crc8_CCITT.c crc8_CCITT.h crc16.c crc16.h drv_RS485x.c drv_RS485x.h drv_time.c drv_time.h drv_UUID.c drv_UUID.h PacketParser.c PacketParser.h unicorn_uart_speed.c unicorn_uart_speed.h Unicorn2Routine.c Unicorn2Routine.h crc32Ethernet.c crc32Ethernet.h
  group Global
    ./Global/: dbg_console.c dbg_console.h DeviceUsageStatistics.c DeviceUsageStatistics.h global.h logger.c logger.h ParamSystem.c ParamSystem.h LockUnlock.c LockUnlock.h drv_InternalFMC.c drv_InternalFMC.h
  group LittleFS
    ./LittleFS/: lfs.c lfs.h lfs_storage.c lfs_storage.h lfs_util.c lfs_util.h
  group modbus
    ./Modbus/: CommandParcerModbus.h CommandParcerModbus.c ErrorHandler.h ErrorHandler.c ModbusRtuFrame.h ModbusRtuFrame.c ModbusUtils.h ModbusUtils.c ReadHoldingRegisters.h ReadHoldingRegisters.c ReadInputRegisters.h ReadInputRegisters.c WriteSingleRegister.h WriteSingleRegister.c WriteMultipleRegisters.h WriteMultipleRegisters.c ModbusRtuRoutine.h ModbusRtuRoutine.c ReadFileRecord.h ReadFileRecord.c WriteFileRecord.h WriteFileRecord.c Diagnostics.h Diagnostics.c ReadDeviceIdentification.h ReadDeviceIdentification.c
    ./Modbus/Core/: ModbusCore.c
    ./Modbus/Port/: ModbusRtuPort.c
    ./Modbus/Backend/: ModbusBackendGd32.c
  group deviceInfo
    ./deviceInfo/: deviceDescription.h
software components: CMSIS:CORE 6.2.0, Device:Libopt 3.0.2, Device:Startup 3.0.2, Device:StdPeripherals:ADC 3.0.2, Device:StdPeripherals:CRC 3.0.2, Device:StdPeripherals:DBG 3.0.2, Device:StdPeripherals:DMA 3.0.2, Device:StdPeripherals:FMC 3.0.2, Device:StdPeripherals:GPIO 3.0.2, Device:StdPeripherals:MISC 3.0.2, Device:StdPeripherals:PMU 3.0.2, Device:StdPeripherals:RCU 3.0.2, Device:StdPeripherals:SPI_I2S 3.0.2, Device:StdPeripherals:SYSCFG 3.0.2, Device:StdPeripherals:TIMER 3.0.2, Device:StdPeripherals:USART 3.0.2
